# IAR project KEA128.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\Peripheral; ..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA128.srec
  ILINK.IlinkOutputFile: KEA128.out
  ILINK.IlinkIcfFile: KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drives/inc
    ../../../Libraries/drives/inc/: common.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h
  group drives/src
    ../../../Libraries/drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c
  group Peripheral
    ../../../Libraries/Peripheral/: Peripheral_IIC.c Peripheral_IIC.h Peripheral_MPU6050.c Peripheral_MPU6050.h Peripheral_OLED.c Peripheral_OLED.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_SKEAZ1284.s
    ../../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c
  group user_c
    ../../USER/src/: Interaction.c isr.c LED.c main.c Speed.c
    ../../../Libraries/: version.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: Interaction.h isr.h LED.h Speed.h
